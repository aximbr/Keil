# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CLOCK_SETUP=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./: main.c Nokia5150_MKL25Z.c
software components: RTOS:Config 10.0.1, RTOS:Core 10.0.1, RTOS:Heap 10.0.1, RTOS:Timers 10.0.1, CMSIS:CORE 5.1.2, Device:Startup 2.5.0
