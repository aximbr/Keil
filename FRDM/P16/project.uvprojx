# Keil uVision project project.uvprojx, settings and files
target KL25Z128 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Micrium\Software\uC-CPU;.\Micrium\Software\uC-CPU\ARM-Cortex-M\ARMv6-M\ARM;.\Micrium\Software\uC-LIB;.\Micrium\Software\uCOS-III\Source;.\Micrium\Software\uCOS-III\Ports\ARM-Cortex-M\ARMv6-M\ARM;.\cfg
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group APP
    ./: app.c
  group uC-CPU
    ./Micrium/Software/uC-CPU/: cpu_core.c
    ./Micrium/Software/uC-CPU/ARM-Cortex-M/ARMv6-M/: cpu_c.c
    ./Micrium/Software/uC-CPU/ARM-Cortex-M/ARMv6-M/ARM/: cpu_a.asm
  group uC-LIB
    ./Micrium/Software/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uCOS-III
    ./Micrium/Software/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ./Micrium/Software/uCOS-III/Ports/ARM-Cortex-M/ARMv6-M/: os_cpu_c.c
    ./Micrium/Software/uCOS-III/Ports/ARM-Cortex-M/ARMv6-M/ARM/: os_cpu_a.s
  group cfg
    ./cfg/: cpu_cfg.h lib_cfg.h os_cfg.h os_cfg_app.h
software components: CMSIS:CORE 5.1.2, Device:Startup 2.5.0
