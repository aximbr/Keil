# Keil uVision project project.uvprojx, settings and files
target TM4C123 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TM4C123GH6PM,SSD1306_USE_I2C
  c include: .\ssd1306;.\HMC5883L;..\;.\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c conv_to_string.c hal_i2c.c
  group ssd1306
    ./ssd1306/: ssd1306.c ssd1306.h ssd1306_fonts.h ssd1306_fonts.c
  group HMC5883
    ./HMC5883L/: HMC5883L.c
software components: RTOS:Config 10.0.1, RTOS:Core 10.0.1, RTOS:Heap 10.0.1, RTOS:Timers 10.0.1, CMSIS:CORE 5.1.2, Device:Startup 1.0.1
