# Keil uVision project project.uvprojx, settings and files
target MSP432P401R (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.5
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Micrium\Software\uC-CPU;.\Micrium\Software\uC-CPU\ARM-Cortex-M\ARMv7-M\ARM;.\Micrium\Software\uC-LIB;.\Micrium\Software\uCOS-III\Source;.\Micrium\Software\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\ARM;.\cfg
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group App
    ./: app.c
  group uc-CPU
    ./Micrium/Software/uC-CPU/: cpu_core.c
    ./Micrium/Software/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ./Micrium/Software/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm
  group uc-LIB
    ./Micrium/Software/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uCOS-III
    ./Micrium/Software/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ./Micrium/Software/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ./Micrium/Software/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu_a.asm
  group cfg
    ./cfg/: cpu_cfg.h lib_cfg.h os_cfg.h os_cfg_app.h
  group BSP
    ./: bsp_a.s
software components: CMSIS:CORE 5.1.2, Device:Startup 3.2.2
