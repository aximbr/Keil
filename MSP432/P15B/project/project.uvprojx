# Keil uVision project project.uvprojx, settings and files
target MSP432 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.5
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __MSP432P401R__,SSD1306_USE_I2C,
  c include: ..\driverlib;.\ssd1306;.\;.\HMC5883L
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group src
    ./: main.c conv_to_string.c hal_i2c.c
  group SSD1306
    ./ssd1306/: ssd1306.c ssd1306_fonts.c
  group driverlib
    ../driverlib/: i2c.c systick.c interrupt.c cs.c cpu.c sysctl.c wdt_a.c flash.c pcm.c rtc_c.c gpio.c
  group HMC8853
    ./HMC5883L/: HMC5883L.c
software components: RTOS:Config 10.0.1, RTOS:Core 10.0.1, RTOS:Heap 10.0.1, RTOS:Timers 10.0.1, CMSIS:CORE 5.1.2, Device:Startup 3.2.2
