# Keil uVision project template_msp432_driverlib.uvprojx, settings and files
target Projeto (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.5
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template_msp432_driverlib
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MSP432P401R,SSD1306_USE_I2C
  c include: ..\driverlib;.\ssd1306;..\project
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group src
    ./: main.c i2c_driver.c my_tick.c
  group drvlib
    ../driverlib/: adc14.c aes256.c comp_e.c cpu.c crc32.c cs.c dma.c flash.c fpu.c gpio.c i2c.c interrupt.c mpu.c pcm.c pmap.c pss.c ref_a.c reset.c rtc_c.c spi.c sysctl.c systick.c timer_a.c timer32.c uart.c wdt_a.c
  group ssd1306
    ./ssd1306/: ssd1306.c ssd1306_fonts.c
software components: CMSIS:CORE 5.1.2, Device:Startup 3.2.2
